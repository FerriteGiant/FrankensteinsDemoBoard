# Keil uVision project game.uvprojx, settings and files
target Game (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: game
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source
    ./: boids.c chargepump.c DisplayTests.c fonts.c IO.c main.c piano.c pong.c screen.c SoundEffects.c boids.h chargepump.h DisplayTests.h fonts.h IO.h pong.h random.h screen.h tm4c123gh6pm.h random.s
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.1
